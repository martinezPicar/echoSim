options:
  parameters:
    author: amp
    generate_options: qt_gui
    id: gr_meteor
    output_language: python
    title: Meteor Scatter Simulation
  states: {}

blocks:
- name: beacon_freq
  id: variable
  parameters:
    value: 49.97e6
  states: {}
- name: burst_duration
  id: variable
  parameters:
    value: '3.0'
  states: {}
- name: dShift
  id: variable
  parameters:
    value: '0'
  states: {}
- name: fade_rate
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: noiseLevel
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,6
    label: Noise Level
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0'
    widget: slider
  states: {}
- name: overSW
  id: variable_qtgui_toggle_switch
  parameters:
    gui_hint: 0,1,1,1
    initPressed: 'False'
    label: Overderdense
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {state: disabled}
- name: overSW
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 0,1,1,1
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {state: disabled}
- name: qtgui_levelgauge_0
  id: qtgui_levelgauge
  parameters:
    gui_hint: 0,0,1,2
    isVertical: 'False'
    label: Doppler
    maximum: '-10'
    minimum: '-10'
    showValue: 'True'
    type: real
    value: dShift
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: underSW
  id: variable_qtgui_toggle_switch
  parameters:
    gui_hint: 0,0,1,1
    initPressed: 'False'
    label: Underdense
    pressed: '1'
    released: '0'
    switchOffBackground: white
    type: int
    value: '0'
  states: {state: disabled}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noiseLevel
    comment: Noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    alias: Beacon
    amp: '1'
    comment: Beacon
    freq: beacon_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_2
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {state: disabled}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_source_0_0_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_source_0_0_0_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Underdense Meteor Envelope
    repeat: 'True'
    type: complex
    vector: ([0.0]*100000 + [np.exp(-x/4000.0) for x in range(10000)] + [0.0]*100000)
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    comment: Overdense Meteor Envelope [Deep Seek]
    repeat: 'True'
    type: complex
    vector: np.concatenate([np.linspace(0,1,int(0.01*samp_rate)), 0.8+0.2*np.sin(2*np.pi*fade_rate*np.linspace(0,burst_duration-0.11,int((burst_duration-0.11)*samp_rate))), np.linspace(0.8,0,int(0.1*samp_rate))])
  states: {state: disabled}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    comment: Overdense Meteor Envelope (AMP)
    repeat: 'True'
    type: complex
    vector: ([0.0]*100000 + [1.0]*8000000 + [0.0]*1000000)
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import random\nfrom gnuradio import gr\nimport pmt\n\nclass blk(gr.sync_block):\n    def __init__(self):\n        gr.sync_block.__init__(\n            self,\n            name=\"RandomFreqUpdater\",\n            in_sig=None,\n            out_sig=None\n        )\n\n        # Add a message output port\n        self.message_port_register_out(pmt.intern(\"freq_out\"))\n\n        self.counter = 0\n        self.current_freq = 0\n\n    def work(self, input_items, output_items):\n        self.counter += 1\n\n        if self.counter % 100 == 0:   # update periodically\n            self.current_freq = random.uniform(-10, 10)\n            self.set_var(\"dShift\", self.current_freq)\n\n            # publish as PMT float\n            self.message_port_pub(\n                pmt.intern(\"freq_out\"),\n                pmt.from_double(self.current_freq)\n            )\n\n        return 0\n\n"
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    alias: doppler_shift
    center_freq: '200'
    comment: Doppler Shift
    decim: '1'
    samp_rate: samp_rate
    taps: '[1]'
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    alias: doppler_shift2
    center_freq: '400'
    comment: Doppler Shift
    decim: '1'
    samp_rate: samp_rate
    taps: '[1]'
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    alias: doppler_shift
    center_freq: '-10'
    comment: Doppler Shift
    decim: '1'
    samp_rate: samp_rate
    taps: '[1]'
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
    wintype: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: beacon_freq
    fftsize: '2048'
    gui_hint: 1,0,5,4
    plotconst: 'False'
    plotfreq: 'False'
    plottime: 'False'
    rate: '.666'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 1,4,5,4
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '3'
    ymin: '-3'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 1,4,5,4
    name: Random Trigger
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '3'
    ymin: '-3'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '2048'
    legend: 'False'
    type: complex
    update_time: '0.1'
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_1, '0']
- [blocks_add_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '2']
- [blocks_multiply_xx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_multiply_xx_0_2, '1']
- [blocks_multiply_xx_0_0_0, '0', blocks_multiply_xx_0_1, '1']
- [blocks_multiply_xx_0_1, '0', blocks_add_xx_0, '3']
- [blocks_multiply_xx_0_1, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_multiply_xx_0_2, '0', blocks_multiply_xx_0, '1']
- [blocks_nlog10_ff_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_null_source_0_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_null_source_0_0_0, '0', blocks_multiply_xx_0_0_0, '0']
- [blocks_null_source_0_0_0_0, '0', blocks_add_xx_0, '3']
- [blocks_throttle2_0, '0', qtgui_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', blocks_multiply_xx_0_2, '1']
- [blocks_vector_source_x_0, '0', freq_xlating_fir_filter_xxx_0_1, '0']
- [blocks_vector_source_x_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [blocks_vector_source_x_0_0, '0', blocks_multiply_xx_0_2, '1']
- [epy_block_0, freq_out, freq_xlating_fir_filter_xxx_0_1, freq]
- [epy_block_0, freq_out, qtgui_levelgauge_0, value]
- [freq_xlating_fir_filter_xxx_0, '0', blocks_add_xx_0, '2']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_add_xx_0, '3']
- [freq_xlating_fir_filter_xxx_0_1, '0', blocks_multiply_xx_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
