options:
  parameters:
    author: amp
    generate_options: qt_gui
    id: gr_meteor
    output_language: python
    title: Meteor Scatter Simulation
  states: {}

blocks:
- name: beacon_freq
  id: variable
  parameters:
    value: 49.97e6
  states: {}
- name: burst_duration
  id: variable
  parameters:
    value: '3.0'
  states: {}
- name: dShift
  id: variable
  parameters:
    value: '0'
  states: {state: disabled}
- name: fade_rate
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: noiseLevel
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,6
    label: Noise Level
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0'
    widget: slider
  states: {}
- name: overSW
  id: variable_qtgui_toggle_switch
  parameters:
    gui_hint: 0,1,1,1
    initPressed: 'False'
    label: Overderdense
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {state: disabled}
- name: overSW
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 0,1,1,1
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {state: disabled}
- name: qtgui_levelgauge_0
  id: qtgui_levelgauge
  parameters:
    gui_hint: 0,0,1,2
    isVertical: 'False'
    label: 'Doppler:'
    maximum: '100'
    minimum: '-100'
    position: '2'
    scaleFactor: '100'
    showValue: 'True'
    type: real
    value: dShift
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: underSW
  id: variable_qtgui_toggle_switch
  parameters:
    gui_hint: 0,0,1,1
    initPressed: 'False'
    label: Underdense
    pressed: '1'
    released: '0'
    switchOffBackground: white
    type: int
    value: '0'
  states: {state: disabled}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noiseLevel/10
    comment: Noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    alias: Beacon
    amp: '1'
    comment: Beacon
    freq: beacon_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '16000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/amp/sw/meteor_output.bin
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0.75'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_2
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_2_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_source_0_0_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Underdense Meteor Envelope
    repeat: 'True'
    type: complex
    vector: ([0.0]*100000 + [np.exp(-x/4000.0) for x in range(10000)] + [0.0]*100000)
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    comment: Overdense Meteor Envelope [Deep Seek]
    repeat: 'True'
    type: complex
    vector: np.concatenate([np.linspace(0,1,int(0.01*samp_rate)), 0.8+0.2*np.sin(2*np.pi*fade_rate*np.linspace(0,burst_duration-0.11,int((burst_duration-0.11)*samp_rate))), np.linspace(0.8,0,int(0.1*samp_rate))])
  states: {state: disabled}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    comment: Overdense Meteor Envelope (AMP)
    repeat: 'True'
    type: complex
    vector: ([0.0]*100000 + [1.0]*8000000 + [0.0]*1000000)
  states: {state: disabled}
- name: blocks_vector_source_x_0_1
  id: blocks_vector_source_x
  parameters:
    comment: Underdense Meteor Envelope
    repeat: 'True'
    type: complex
    vector: ([0.0]*50000 + [np.exp(-x/4000) for x in range(10000)] + [0.0]*150000)
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import random\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass blk(gr.sync_block):\n    def __init__(self):\n        gr.sync_block.__init__(\n            self,\n            name=\"Random dShift Publisher\",\n            in_sig=None,\n            out_sig=[np.float32]   # optional float output stream\n        )\n        self.counter = 0\n        self.current_val = 0.0\n\n        # Message output port for variable updates\n        self.message_port_register_out(pmt.intern(\"freq_out\"))\n\n    def work(self, input_items, output_items):\n        out = output_items[0]\n\n        for i in range(len(out)):\n            if self.counter % 100 == 0:\n                self.current_val = random.uniform(-15, 15)\n\n                # Build PMT pair: (variable name, value)\n                msg = pmt.cons(\n                    pmt.intern(\"dShift\"),\n                    pmt.from_double(self.current_val)\n                )\n\n                # Publish the message\n                self.message_port_pub(pmt.intern(\"freq_out\"), msg)\n\n                # Print to terminal\n                # print(f\"[Random dShift Publisher] dShift = {self.current_val:.3f}\")\n\n            out[i] = self.current_val\n            self.counter += 1\n\n        return len(out)\n\n"
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    alias: doppler_shift2
    center_freq: '10'
    comment: Doppler Shift +
    decim: '1'
    samp_rate: samp_rate
    taps: '[1]'
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    alias: doppler_shift2
    center_freq: '400'
    comment: Doppler Shift
    decim: '1'
    samp_rate: samp_rate
    taps: '[1]'
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    alias: doppler_shift
    center_freq: '0'
    comment: Doppler Shift
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -samp_rate/(2), samp_rate/(2), 10)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '500'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
    wintype: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    avg: '1'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 0,0,1,2
    label1: 'Doppler:'
    max: '15'
    min: '-15'
    name: Random Generator
    type: float
    unit1: Hz
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: beacon_freq
    fftsize: '2048'
    gui_hint: 1,0,5,4
    plotconst: 'False'
    plotfreq: 'False'
    plottime: 'False'
    rate: '.666'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 1,4,5,4
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '3'
    ymin: '-3'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '2048'
    legend: 'False'
    type: complex
    update_time: '0.1'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '16'
    taps: firdes.low_pass(1.0,16000,500,200,window.WIN_HAMMING)
    type: fff
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_1, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_2_0, '0']
- [blocks_add_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_complex_to_mag_0, '0', rational_resampler_xxx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_xx_0, '0', freq_xlating_fir_filter_xxx_0_1, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '2']
- [blocks_multiply_xx_0_0, '0', blocks_multiply_xx_0_2, '1']
- [blocks_multiply_xx_0_0_0, '0', blocks_multiply_xx_0_1, '1']
- [blocks_multiply_xx_0_1, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_multiply_xx_0_2, '0', blocks_multiply_xx_0, '1']
- [blocks_nlog10_ff_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_null_source_0_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_null_source_0_0_0, '0', blocks_multiply_xx_0_0_0, '0']
- [blocks_throttle2_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle2_0, '0', low_pass_filter_0, '0']
- [blocks_throttle2_0, '0', qtgui_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_vector_source_x_0, '0', blocks_multiply_xx_0_2, '1']
- [blocks_vector_source_x_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [blocks_vector_source_x_0_0, '0', blocks_multiply_xx_0_2, '1']
- [blocks_vector_source_x_0_1, '0', freq_xlating_fir_filter_xxx_0, '0']
- [epy_block_0, '0', blocks_null_sink_0, '0']
- [epy_block_0, '0', qtgui_number_sink_0, '0']
- [epy_block_0, freq_out, freq_xlating_fir_filter_xxx_0_1, freq]
- [epy_block_0, freq_out, qtgui_levelgauge_0, value]
- [freq_xlating_fir_filter_xxx_0, '0', blocks_multiply_xx_0_2_0, '1']
- [freq_xlating_fir_filter_xxx_0_1, '0', blocks_multiply_xx_0, '1']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
